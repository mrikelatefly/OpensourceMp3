# Keil uVision project Ant_V1_Demo.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103RG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FrameBox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10_HD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\Lib\INC;..\System\DELAY;..\System\SYS;..\System\USART;..\User;..\Tools\inc;..\Head\LCD;..\Head\SPI;..\Head\Eventscan;..\Head\W25Q128;..\Head\MicroSD;..\Head\Key;..\Head\VS1053B;..\FAT;..\FAT\src;..\FAT\exfuns
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group Lib
    ../Lib/SRC/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group FAT
    ../FAT/src/: diskio.c ff.c ffconf.h integer.h
    ../FAT/exfuns/: exfuns.c fattester.c
    ../FAT/src/option/: cc936.c
  group System
    ../System/DELAY/: delay.c
    ../System/SYS/: sys.c
    ../System/USART/: usart.c
  group Head
    ../Head/SPI/: SPI.c
    ../Head/W25Q128/: w25qxx.c
    ../Head/MicroSD/: MicroSD.c
    ../Head/Key/: Key.c
    ../Head/VS1053B/: vs10xx.c
    ../Head/LCD/: LCD_2_0.c
  group Tools
    ../Tools/src/: StringOperation.c FrameBox.c malloc.c Player.c
